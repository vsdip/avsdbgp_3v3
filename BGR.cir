** BGR **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Ankur
* Mon, Jun 08, 2020 13:09:52
*

*## Multisim Component pnp4 ##*
qpnp4 0 0 ctat 2N3702__BJT_PNP__1

*## Multisim Component pnp2 ##*
qpnp2 0 0 vd3 2N3702__BJT_PNP__1

*## Multisim Component R2 ##*
rR2 vref ctat 134000 vresR2
.model vresR2 r(  )

*## Multisim Component P3 ##*
mP3 vref 5 VDD VDD PMOS__TRANSISTORS_VIRTUAL__1__1  L=2e-005  W=5e-006

*## Multisim Component VDD ##*
VDDVDD  VDD 0 dc 3.3

*## Multisim Component P2 ##*
mP2 2 5 VDD VDD PMOS__TRANSISTORS_VIRTUAL__1__1  L=2e-005  W=5e-006

*## Multisim Component N2 ##*
mN2 5 2 vd2 0 NMOS__TRANSISTORS_VIRTUAL__1__1  L=2e-005  W=5e-006

*## Multisim Component N1 ##*
mN1 2 2 vd1 0 NMOS__TRANSISTORS_VIRTUAL__1__1  L=2e-005  W=5e-006

*## Multisim Component P1 ##*
mP1 5 5 VDD VDD PMOS__TRANSISTORS_VIRTUAL__1__1  L=2e-005  W=5e-006

*## Multisim Component R1 ##*
rR1 vd2 vd3 3830 vresR1
.model vresR1 r(  )

*## Multisim Component pnp3 ##*
qpnp3 0 0 vd1 2N3702__BJT_PNP__1

*## Multisim Component pnp1 ##*
qpnp1 0 0 vd3 2N3702__BJT_PNP__1

.MODEL 2N3702__BJT_PNP__1   PNP(Is=650.6E-18 Xti=3 Eg=1.11 Vaf=115.7 Bf=133.8 Ne=1.832
+               Ise=97.16f Ikf=1.081 Xtb=1.5 Br=3.73 Nc=2 Isc=0 Ikr=0 Rc=.715
+               Cjc=14.76p Mjc=.5383 Vjc=.75 Fc=.5 Cje=19.82p Mje=.3357 Vje=.75
+               Tr=114.1n Tf=761.3p Itf=.65 Vtf=5 Xtf=1.7 Rb=10)

.model NMOS__TRANSISTORS_VIRTUAL__1__1   nmos
+ (
+  Level=10
+ )

.model PMOS__TRANSISTORS_VIRTUAL__1__1 pmos
+ (
+  Level=10
+ )
